# Keil uVision project Cortex-M3_Execute_for_lpc1700.uvproj, settings and files
target DebugInFlash (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Cortex-M3-vx.xx +hex
  c flags: Optim=1
  c define: DEBUG
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\cfg_file\Startup\InChip.sct
  link misc: --entry __main
  group USER_CODE
    ./USER_CODE/: main.c lcd.c keypad.c function.c timer.c mdb.c menu.c DevTaskFun.c SaleTaskFun.c uart.c gprs.c drv.c hopper.c MdbNote.c gbahr1.c MdbCoin.c PulseCoin.c BillAcceptor.c CoinAcceptor.c Changer.c dispmenu.c menuinit.c language.c pcf8563t.c i2c.c RealTime.c ITL.c DebugTrace.c VMC_PC.c ScriptGetAddress.c UCSGBK.c zikuDriver.c PituFont.c SelectKey.c uart1.c task.c reader.c acdc.c
  group ZY_CODE
    ./ZY_CODE/Startup/: LPC1700PinCfg.c target.c vector_table.c lpc1700.h target.h
    ./ZY_CODE/: firmware.h
    ./ZY_CODE/zy_if/: zy_if.c zy_if.h
  group cfg_file
    ./: config.h
    ./cfg_file/: target_cfg.h
    ./cfg_file/Startup/: LPC1700PinCfg.h rt_sys_s.s rt_sys_c.c vector_cfg.h
    ./cfg_file/zy_if/: zy_if_cfg.h
    ./cfg_file/uCOSII/: OS_CFG.H
  group uCOS-II
    ./ZY_CODE/uCOS-II/: OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C uCOS_II.H INCLUDES.H OS_CORE.C OS_FLAG.C
    ./ZY_CODE/uCOS-II/cpu/: os_cpu.h Os_cpu_c.c
    ./ZY_CODE/uCOS-II/hook/: uCOS-II hook.lib
  group driver
    ./driver/: lpc17xx_uart.c UartDev_LPC17xx.c lpc17xx_uart.h UartDev.h UartDev_LPC17xx.h lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_gpio.c UartDev_LPC17xx_polling.c core_cm3.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_gpdma.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_wdt.c system_LPC17xx.c AT45DB.C spi.c
target Release (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: Cortex-M3 Execute for lpc1700
  c flags: Optim=1
  c define: RELEASE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\cfg_file\Startup\InChip.sct
  link misc: --entry __main
